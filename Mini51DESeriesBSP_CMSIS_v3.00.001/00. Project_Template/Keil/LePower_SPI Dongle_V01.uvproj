# Keil uVision project LePower_SPI Dongle_V01.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: (Generic) Mini51 Series Nuvoton
  cpu: CLOCK(24000000) CPUTYPE("Cortex-M0")
  output: LePower_SPI Dongle_V01
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1
  c include: ..\..\Library\CMSIS\Include;..\..\Library\Device\Nuvoton\Mini51Series\Include;..\..\Library\StdDriver\inc
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../../Library/Device/Nuvoton/Mini51Series/Source/: system_Mini51Series.c
    ../../Library/Device/Nuvoton/Mini51Series/Source/ARM/: startup_Mini51Series.s
  group Library
    ../../Library/StdDriver/src/: retarget.c uart.c sys.c
  group User
    ../: main.c
