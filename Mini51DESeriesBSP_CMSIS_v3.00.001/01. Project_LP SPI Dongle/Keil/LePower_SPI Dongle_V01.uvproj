# Keil uVision project LePower_SPI Dongle_V01.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: (Generic) Mini51 Series Nuvoton
  cpu: CLOCK(24000000) CPUTYPE("Cortex-M0")
  output: LePower_SPI Dongle_V01 +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1
  c include: ..\..\Library\CMSIS\Include;..\..\Library\Device\Nuvoton\Mini51Series\Include;..\..\Library\StdDriver\inc
  group CMSIS
    ../../Library/Device/Nuvoton/Mini51Series/Source/: system_Mini51Series.c
    ../../Library/Device/Nuvoton/Mini51Series/Source/ARM/: startup_Mini51Series.s
  group Library
    ../../Library/StdDriver/src/: retarget.c uart.c sys.c clk.c timer.c spi.c
  group User
    ../: main.c
