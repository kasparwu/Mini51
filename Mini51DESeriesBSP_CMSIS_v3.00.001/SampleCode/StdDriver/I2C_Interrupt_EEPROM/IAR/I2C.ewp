# IAR project I2C.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Mini51DE series Nuvoton Mini51DE series (Mini51DE,Mini52DE,Mini54DE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\Mini51Series\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: I2C.bin
  ILINK.IlinkOutputFile: I2C.out
configuration Release (ARM)
  as the first configuration, except:
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../Library/Device/Nuvoton/Mini51Series/Source/IAR/: startup_Mini51Series.s
    ../../../../Library/Device/Nuvoton/Mini51Series/Source/: system_Mini51Series.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c i2c.c retarget.c sys.c uart.c
  group User
    ../: main.c
