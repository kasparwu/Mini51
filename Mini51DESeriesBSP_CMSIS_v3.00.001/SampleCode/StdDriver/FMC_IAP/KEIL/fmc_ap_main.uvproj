# Keil uVision project fmc_ap_main.uvproj, settings and files
target APROM_code (ARM-ADS)
  device: (Generic) Mini51 Series Nuvoton
  cpu: CLOCK(24000000) CPUTYPE("Cortex-M0")
  output: APROM_code
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c include: ..\..\..\..\Library\Device\Nuvoton\Mini51Series\Include;..\..\..\..\Library\CMSIS\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  link misc: --map --first='startup_Mini51Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/Mini51Series/Source/: system_Mini51Series.c
    ../../../../Library/Device/Nuvoton/Mini51Series/Source/ARM/: startup_Mini51Series.s
  group User
    ../: APROM_main.c
    ./: ap_image.s
  group Library
    ../../../../Library/StdDriver/src/: retarget.c uart.c sys.c fmc.c
