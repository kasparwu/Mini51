# IAR project Interrupt.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Mini51DE series Nuvoton Mini51DE series (Mini51DE,Mini52DE,Mini54DE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\..\..\Library\Nu-LB-Mini51\inc; $PROJ_DIR$..\..\..\..\..\Library\StdDriver\inc; $PROJ_DIR$..\..\..\..\..\Library\Device\Nuvoton\Mini51Series\Include; $PROJ_DIR$..\..\..\..\..\Library\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Interrupt.bin
  ILINK.IlinkOutputFile: Interrupt.out
  ILINK.IlinkIcfFile: Mini51.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 0
  group CMSIS
    ../../../../Library/Device/Nuvoton/Mini51Series/Source/IAR/: startup_Mini51Series.s
    ../../../../Library/Device/Nuvoton/Mini51Series/Source/: system_Mini51Series.c
  group Library
    ../../../../Library/Nu-LB-Mini51/src/: Ascii_Table.c LCD_Driver.c
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c sys.c uart.c
  group User
    ../: main.c
