# IAR project I2C_SW.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Mini51DE series Nuvoton Mini51DE series (Mini51DE,Mini52DE,Mini54DE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\Mini51Series\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\Nu-LB-Mini51\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: I2C_SW.bin
  ILINK.IlinkOutputFile: I2C_SW.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c i2c.c retarget.c sys.c uart.c
    ../../../../Library/Nu-LB-Mini51/src/: i2c_software_gpio.c
  group Library/CMSIS
    ../../../../Library/Device/Nuvoton/Mini51Series/Source/IAR/: startup_Mini51Series.s
    ../../../../Library/Device/Nuvoton/Mini51Series/Source/: system_Mini51Series.c
  group User
    ../: i2c_hardware.c main.c
