# IAR project LCD_DEMO.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Mini51DE series Nuvoton Mini51DE series (Mini51DE,Mini52DE,Mini54DE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __LCDDISPLAY_BTL001_H
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\..\..\library\CMSIS\Include; $PROJ_DIR$..\..\..\..\..\library\Device\Nuvoton\Mini51Series\Include; $PROJ_DIR$..\..\..\..\..\library\StdDriver\inc; $PROJ_DIR$..\..\..\..\..\library\Nu-LB-Mini51\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: LCD_DEMO.bin
  ILINK.IlinkOutputFile: LCD_DEMO.out
  ILINK.IlinkIcfFile: Mini51Series.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 1
  group CMSIS
    ../../../../Library/Device/Nuvoton/Mini51Series/Source/IAR/: startup_Mini51Series.s
    ../../../../Library/Device/Nuvoton/Mini51Series/Source/: system_Mini51Series.c
  group Library
    ../../../../Library/Nu-LB-Mini51/src/: ascii_table.c lcd_driver.c
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c sys.c timer.c
  group User
    ../: main.c
