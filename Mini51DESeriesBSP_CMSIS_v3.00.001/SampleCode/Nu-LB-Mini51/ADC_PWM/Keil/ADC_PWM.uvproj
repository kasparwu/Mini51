# Keil uVision project ADC_PWM.uvproj, settings and files
target ADC_PWM (ARM-ADS)
  device: (Generic) Mini51 Series Nuvoton
  cpu: CLOCK(24000000) CPUTYPE("Cortex-M0")
  output: ADC_PWM
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 wLevel=2
  c include: ..\..\..\..\Library\Device\Nuvoton\Mini51Series\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Nu-LB-Mini51\inc
  library: MicroLIB
  link misc: --map --first='startup_Mini51Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/Mini51Series/Source/: system_Mini51Series.c
    ../../../../Library/Device/Nuvoton/Mini51Series/Source/ARM/: startup_Mini51Series.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c adc.c clk.c sys.c gpio.c
    ../../../../Library/Nu-LB-Mini51/src/: lcd_driver.c ascii_table.c
