# IAR project Timer_WDT.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Mini51DE series Nuvoton Mini51DE series (Mini51DE,Mini52DE,Mini54DE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\Mini51Series\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\Nu-LB-Mini51\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Timer_WDT.bin
  ILINK.IlinkOutputFile: Timer_WDT.out
  ILINK.IlinkIcfFile: Timer_WDT.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group CMSIS
    ../../../../Library/Device/Nuvoton/Mini51Series/Source/IAR/: startup_Mini51Series.s
    ../../../../Library/Device/Nuvoton/Mini51Series/Source/: system_Mini51Series.c
  group Library
    ../../../../Library/Nu-LB-Mini51/src/: ascii_table.c lcd_driver.c
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c sys.c
  group User
    ../: main.c
